require ${@"core-image-renesas-base-ccpf-sk.inc" if "rcar-gen3" in d.getVar("OVERRIDES") else ""}
