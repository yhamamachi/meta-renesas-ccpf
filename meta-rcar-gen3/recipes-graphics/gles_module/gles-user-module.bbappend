PROVIDES_append = " virtual/libgl"

